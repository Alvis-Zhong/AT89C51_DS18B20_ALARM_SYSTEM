# Keil uVision project bsp_tem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: bsp_tem +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DS18B20;.\LCD1602;..\BSP;.\key_set;.\Warning
  group Source Group 1
    ./: STARTUP.A51
  group DS18B20
    ./DS18B20/: bsp_ds18b20.c bsp_ds18b20.h
  group LCD1602
    ./LCD1602/: bsp_lcd1602.c
  group KEY_SET
    ./key_set/: bsp_key.c
  group WARNING
    ./Warning/: bsp_warn.c
  group USER
    ./: main.c
